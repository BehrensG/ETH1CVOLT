File: HARDWARE/ETH1CVOLT/ETH1CVOLT.kicad_pcb (KiCad board)
At the start: 2 copper layers, 160 x 100 mm, 162 parts, among them J1 20021111-00010T4LF, J2 RJ45_Wuerth_7499010121A, J3 1715721, K1 SILxx-1Cxx-51x, Q1 CSD18501Q5A, Q2 MMBT3904, U1 STM32H743VITx, U10 MAX44241AUA+, U11 ADP7142ARDZ-5.0, U12 ADG419BR, U14 ADR1399KEZ, U15 TSR0.5-2433, U16 TEC2-2419WI, U17 TMR4-2423WI, U19 ADA4522-2, U2 24LC08B-E/MS, U20 OPA2196xD, U21 ISO7761FDBQ, U22 ISO7761FDBQ, U23 ADP7142ARDZ-5.0, U24 TPS7A39, U3 LAN8742A, U4 MAX5719GSD+, U5 OPA4189xPW, U6 LTC2400CS8#TRPBF, U7 INA159AIDGKT, U8 ADG419BR, U9 DG412xUE

Commit message: Development
Parts:
- removed JP10, JP11, JP12, JP13, JP8, JP9: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
- removed RN4, RN6, RN7, RN8, RN9: MPMT2002QT0, Package_TO_SOT_SMD:SOT-23
- added C100: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 75.1)
- added C101: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 79.4)
- added C102: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (289.9, 90.1)
- added C103: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (289.9, 94.3)
- added C104: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (289.9, 98.6)
- added C105: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (289.9, 102.8)
- added C106: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (277.9, 95.8)
- added C107: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (277.9, 98.3)
- added C30: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (49.3, 106.6)
- added C31: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (49.3, 109.1)
- added C32: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (49.3, 111.6)
- added C33: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (49.3, 114.1)
- added C34: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (38.8, 120.2)
- added C44: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (23.7, 106.6)
- added C45: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (23.7, 109.1)
- added C46: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (23.7, 111.6)
- added C47: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (23.7, 114.1)
- added C48: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (38.8, 122.7)
- added C49: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (293.2, 62.4)
- added C50: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (293.2, 55.4)
- added C51: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (293.2, 57.9)
- added C55: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (239.5, 106.3)
- added C56: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (239.5, 110.6)
- added C57: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 49.6)
- added C58: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 53.9)
- added C59: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 58.1)
- added C60: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 62.4)
- added C61: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 66.6)
- added C62: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 70.9)
- added C63: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 75.1)
- added C64: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (257.3, 79.4)
- added C65: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 49.6)
- added C66: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 53.9)
- added C67: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 58.1)
- added C68: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 62.4)
- added C69: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 66.6)
- added C70: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 70.9)
- added C71: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 75.1)
- added C72: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (263.3, 79.4)
- added C73: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 49.6)
- added C74: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 53.9)
- added C77: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 58.1)
- added C87: C, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (269.3, 62.4)
- added C89: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (84.9, 97.4)
- added C90: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 66.6)
- added C91: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 70.9)
- added C92: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 75.1)
- added C93: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (269.3, 79.4)
- added C94: 4u7/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 49.6)
- added C95: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 53.9)
- added C96: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 58.1)
- added C97: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 62.4)
- added C98: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 66.6)
- added C99: 10u/50V/X7R, Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder, F.Cu at (275.3, 70.9)
- added D6: MMSZ5240C-HE3_A-08, Diode_SMD:D_SOD-123, F.Cu at (25.6, 101.0)
- added D7: 1N4148W, Diode_SMD:D_SOD-123, F.Cu at (49.6, 119.6)
- added D8: 1N4148W, Diode_SMD:D_SOD-123, F.Cu at (53.9, 107.5)
- added D9: SMAJ28CA, Diode_SMD:D_SMA, F.Cu at (38.5, 93.9)
- added J4: TSW-102-23-G-S, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, F.Cu at (50.9, 87.7)
- added J5: 1827868, Connector_Phoenix_MC:PhoenixContact_MC_1,5_2-GF-3.81_1x02_P3.81mm_Horizontal_ThreadedFlange_MountHole, F.Cu at (80.9, 50.1)
- added J6: FCR7350R, ETH1CVOLT_A:S16N-PC, F.Cu at (261.0, 94.9)
- added J7: FCR7350B, ETH1CVOLT_A:S16N-PC, F.Cu at (215.8, 96.9)
- added JP2: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 50.9)
- added JP3: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 57.4)
- added JP4: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 64.0)
- added JP5: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 70.6)
- added JP6: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 77.2)
- added JP7: SolderJumper_2_Open, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (240.7, 83.8)
- added K2: SIL05-1C90-51D, Relay_THT:Relay_SPDT_StandexMeder_SIL_Form1C, F.Cu at (166.3, 133.4)
- added Q3: 2N7002, Package_TO_SOT_SMD:SOT-23, F.Cu at (33.1, 94.4)
- added R33: 100/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (26.2, 95.5)
- added R34: 0R/5%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (55.5, 86.8)
- added R35: 0R/5%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (37.7, 96.8)
- added R36: 0R/5%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (241.2, 92.3)
- added R37: 0R/5%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (241.2, 98.9)
- added R56: 187k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (285.9, 62.8)
- added R57: 18k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (285.9, 65.3)
- added R68: 1k/1%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (38.7, 113.2)
- added R69: 10k/0.01%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (38.7, 115.7)
- added R70: 1k/1%/100mW, Package_SO:TSSOP-16_4.4x5mm_P0.65mm, F.Cu at (37.5, 99.3)
- added R71: 10k/0.01%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (280.5, 91.2)
- added RN1: EXB-V8V330JV, Resistor_SMD:R_Array_Convex_4x0603, F.Cu at (79.6, 90.9)
- added RN2: EXB-V8V103JV, Resistor_SMD:R_Array_Convex_4x0603, F.Cu at (83.7, 90.9)
- added RN3: EXB-38V510JV, Resistor_SMD:R_Array_Convex_4x0603, F.Cu at (87.9, 90.9)
- added TP10: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (48.9, 123.6)
- added TP11: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (42.5, 113.7)
- added TP12: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (280.1, 77.6)
- added TP13: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (283.7, 74.0)
- added TP14: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (283.7, 77.6)
- added TP15: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (287.2, 74.0)
- added TP16: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (287.2, 77.6)
- added TP2: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (46.7, 87.3)
- added TP3: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (46.7, 90.8)
- added TP4: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (46.7, 94.4)
- added TP5: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (246.7, 59.2)
- added TP6: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (46.7, 97.9)
- added TP8: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (250.3, 106.0)
- added TP9: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (280.1, 74.0)
- added U13: OPA192IDR, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (40.9, 108.7)
- added U18: TSR0.5-2465, Converter_DCDC:Converter_DCDC_TRACO_TSR0.5-24xx_TSR0.5-24xxx_THT, F.Cu at (282.1, 52.0)
- added U25: ADA4522-2ARZ-RL, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (52.7, 97.8)
- added U26: 74LV1T08GV, Package_TO_SOT_SMD:SC-74A-5_1.55x2.9mm_P0.95mm, F.Cu at (30.4, 108.6)
- added Y1: NX5032GA-16, ETH1CVOLT_A:NX5032GA, F.Cu at (294.7, 49.8)
- added Y2: NX5032GA-25, ETH1CVOLT_A:NX5032GA, F.Cu at (290.6, 109.3)
- C1, C16, C2, C23, C25, C26, C27, C28, C3, C4, C5: value 0.1u -> 0.1u/100V/X7R
- C10: value 8p -> 2u2/16V/X7R
- C11, C19: value 8p -> 1u/16V/X7R
- C12: value 10u -> 2u2/16V/X7R
- C13: value 2u2 -> 1u/16V/X7R
- C14: value 0.1u -> 10u/16V/X7R; footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- C15: value 2u2 -> 0.1u/100V/X7R
- C17: value 8p -> 0.1u/100V/X7R
- C18, C6, C9: value 0.1u -> 8p/100V/X7R
- C20: value 1u -> 8p/100V/X7R
- C21, C22: value 1u -> 1u/16V/X7R
- C24: value 470p -> 470p/100V/X7R
- C29: value 10u/35V/X7R -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C35: value 10u/35V/X7R -> 10u/50V/X7R; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
- C36: value 10uF/50V/X7R -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C37: value 2,2uF/50V/X7R -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C38: value 2,2uF/50V/X7R -> 10u/50V/X7R; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
- C39, C78, C82: value 4u7/100V -> 4u7/50V/X7R
- C40: value 4u7/35V/X7R -> 100p/100V/X7R; footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C41: value 22u/16V -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C42, C43: value 4u7/100V -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C52: value 1u/50V/X7R -> 0.1u/100V/X7R; footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C53: value 100p/100V/X7R -> 10u/50V/X7R; footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
- C54: value C -> 10u/50V/X7R; footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
- C7, C8: value 1u -> 0.1u/100V/X7R
- C75, C84: value 4u7/100V -> C; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C76, C83: value 10u/100V -> 4u7/50V/X7R
- C79, C88: value 10u/100V -> C; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C80, C86: value 4u7/100V -> 10u/50V/X7R
- C81, C85: value 10u/100V -> 10u/50V/X7R
- D2: value LED -> BAV199; footprint LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder -> Package_TO_SOT_SMD:SOT-23
- D3: value MMSZ5240C-HE3_A-08 -> BAV199; footprint Diode_SMD:D_SOD-123 -> Package_TO_SOT_SMD:SOT-23
- D5: value 1N4148W -> LED; footprint Diode_SMD:D_SOD-123 -> LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
- J2: value RJ45_Wuerth_7499010121A -> 7499010121A
- J3: value 1715721 -> TSW-102-23-G-S; footprint TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
- K1: value SILxx-1Cxx-51x -> SIL05-1C90-51D
- Q2: value MMBT3904 -> 2N7002
- R1, R3, R6, R8: value 10k -> 10k/1%/100mW
- R10, R11: value 560 -> 560/1%/100mW
- R12, R13: value 0R/5%/100mW -> 10k/0.01%/100mW; footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0603_1608Metric
- R15: value 100/1%/100mW -> 0R/5%/100mW; footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Package_SO:TSSOP-16_4.4x5mm_P0.65mm
- R16, R22: value 0R/5%/100mW -> 100/1%/100mW; footprint Package_SO:TSSOP-16_4.4x5mm_P0.65mm -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R17, R18, R19, R20: footprint Package_SO:TSSOP-16_4.4x5mm_P0.65mm -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R2: value 0 -> 0R/5%/100mW
- R21: value 0R/5%/100mW -> 2k67/1%/250mW; footprint Package_SO:TSSOP-16_4.4x5mm_P0.65mm -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R23: value 100k/1%/100mW -> 8k2/0.1%/100mW
- R24: value 2k/1%/100mW -> 20k/0.1%/100mW
- R25: value 2k/1%/100mW -> 9k65/0.1%/100mW
- R26: value 1k/1%/100mW -> OPT; footprint Package_SO:TSSOP-16_4.4x5mm_P0.65mm -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R27: value 165k -> 40k2/0.1%/100mW
- R28: value 10k -> OPT
- R29: value 1k4 -> 68k/0.1%/100mW
- R30: value 174k -> OPT
- R31: value 10k -> 110k/0.1%/100mW
- R32: value 2k4 -> 198k/0.1%/100mW
- R38, R39: value 0 -> 0R/5%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Package_SO:TSSOP-16_4.4x5mm_P0.65mm
- R4, R5: value 4k7 -> 4k7/1%/100mW
- R40: value 2k67/1%/250mW -> 0R/5%/100mW; footprint Resistor_SMD:R_0805_2012Metric -> Package_SO:TSSOP-16_4.4x5mm_P0.65mm
- R41: value 5R1/5%/100mW -> 0R/5%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Package_SO:TSSOP-16_4.4x5mm_P0.65mm
- R42: value 8k2/0.1%/100mW -> 10k/0.01%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R43: value 20k/0.01%/100mW -> 10k/0.01%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R44: value 9k65/0.1%/100mW -> 10k/0.01%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R45: value 40k2/0.1%/100mW -> 10k/0.01%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R46, R47: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R48: value 100/1%/100mW -> 100k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R49: value 100/1%/100mW -> 2k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R50: value 68k/0.1%/100mW -> 2k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R51: value 110k/0.1%/100mW -> 12k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R52: value 198k/0.05%/100mW -> 140k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R53: value OPT -> 160k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R54: value OPT -> 15k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R55: value OPT -> 10k2/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R58: value 10k/0.01%/100mW -> 105k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R59: value 10k/0.01%/100mW -> 182k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R60: value 10k/0.01%/100mW -> 10k5/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R61, R62: value 10k/0.01%/100mW -> R; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R63, R64: value 10k/0.01%/100mW -> 0R/5%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R65: value 10k/0.01%/100mW -> 107k/1%/100mW; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R66: value 0 -> 22k1/1%/100mW
- R67: value 0 -> 100/1%/100mW
- R7: value 1k4 -> 1k4/1%/100mW
- R9: value 12k1 -> 12k1/1%/100mW
- U11: value ADP7142ARDZ-5.0 -> ISO7761FDBQ; footprint Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm -> Package_SO:SSOP-16_3.9x4.9mm_P0.635mm
- U12: value ADG419BR -> ISO7761FDBQ; footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> Package_SO:SSOP-16_3.9x4.9mm_P0.635mm
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Connections:
- net /BLOCK DIAGRAM/Ethernet/ETH_RXN renamed /BLOCK DIAGRAM/ETHERNET/ETH_RXN
- net /BLOCK DIAGRAM/Ethernet/ETH_RXP renamed /BLOCK DIAGRAM/ETHERNET/ETH_RXP
- net /BLOCK DIAGRAM/Ethernet/ETH_TXN renamed /BLOCK DIAGRAM/ETHERNET/ETH_TXN
- net /BLOCK DIAGRAM/Ethernet/ETH_TXP renamed /BLOCK DIAGRAM/ETHERNET/ETH_TXP
- net /BLOCK DIAGRAM/Ethernet/LED1 renamed /BLOCK DIAGRAM/ETHERNET/LED1
- net /BLOCK DIAGRAM/Ethernet/LED2 renamed /BLOCK DIAGRAM/ETHERNET/LED2
- net Net-(U11-SS) renamed /BLOCK DIAGRAM/ISO DIG/MCU_ADC_VOLT_~{CS}
- C10 pad 1: Net-(U1-PH0) -> Net-(C10-Pad1)
- C11 pad 1: Net-(U1-PH1) -> VDD
- C12 pad 1: VDDA -> Net-(C12-Pad1)
- C13 pad 1: Net-(C13-Pad1) -> +3.3V
- C15 pad 1: Net-(C15-Pad1) -> VDDA
- C17 pad 1: Net-(U3-XTAL1/CLKIN) -> +3.3V
- C18 pad 1: +3.3V -> Net-(U3-XTAL1/CLKIN)
- C19 pad 1: Net-(U3-XTAL2) -> +3.3V
- C20 pad 1: +3.3V -> Net-(U3-XTAL2)
- C29 pad 1: Net-(U6-VIN) -> +5VREF_ISO
- C35 pad 1: Net-(U14-+REFF) -> Net-(U6-VIN)
- C36 pad 1: +24V -> +14V_ISO
- C36 pad 2: GND -> GND_ISO
- C37 pad 1: +24V -> -14V_ISO
- C37 pad 2: GND -> GND_ISO
- C38 pad 1: +24V -> Net-(U7A-+)
- C38 pad 2: GND -> GND_ISO
- C39 pad 1: Net-(U15-Vin) -> Net-(U7A-+)
- C39 pad 2: GND -> GND_ISO
- C40 pad 1: Net-(U14-+REFF) -> Net-(J4-Pin_1)
- C41 pad 1: +3.3V -> +5VD_ISO
- C41 pad 2: GND -> GND_ISO
- C42 pad 1: +24V -> +5VREF_ISO
- C42 pad 2: GND -> GND_ISO
- C43 pad 1: +24V -> GND_ISO
- C43 pad 2: GND -> Net-(U10-V+)
- C52 pad 1: Net-(C52-Pad1) -> -22V_ISO
- C53 pad 1: Net-(U5B-+) -> +24V
- C53 pad 2: GND_ISO -> GND
- C54 pad 1: Net-(U24-NR/SS) -> +24V
- C54 pad 2: GND_ISO -> GND
- C6 pad 1: VDD -> Net-(U1-PH0)
- C75 pad 1: +7V_ISO -> Net-(U19-NR/SS)
- C76 pad 1: +7V_ISO -> Net-(U18-Vout)
- C78 pad 1: +5VA_ISO -> GND_ISO
- C78 pad 2: GND_ISO -> -14V_ISO
- C79 pad 1: +5VA_ISO -> Net-(U20-NR/SS)
- C8 pad 1: +3.3V -> /BLOCK DIAGRAM/MCU/NRST
- C80 pad 1: +7V_ISO -> +14V_ISO
- C81 pad 1: +7V_ISO -> GND_ISO
- C81 pad 2: GND_ISO -> -14V_ISO
- C82 pad 1: +5VD_ISO -> +6V5_ISO
- C83 pad 1: +5VD_ISO -> +6V5_ISO
- C84 pad 1: +21V_ISO -> Net-(U23-NR/SS)
- C85 pad 1: +21V_ISO -> +6V5_ISO
- C86 pad 1: GND_ISO -> +6V5_ISO
- C86 pad 2: -21V_ISO -> GND_ISO
- C88 pad 1: GND_ISO -> Net-(U22-SS)
- C88 pad 2: -21V_ISO -> GND_ISO
- C9 pad 1: /BLOCK DIAGRAM/MCU/NRST -> Net-(U1-PH1)
- D1 pad 1: GND_ISO -> -14V_ISO
- D1 pad 2: +5VD_ISO -> +14V_ISO
- D1 pad 3: Net-(D1-K-Pad3) -> /BLOCK DIAGRAM/ADC/MEAS_OUT
- D2 pad 1: Net-(D2-K) -> GND_ISO
- D2 pad 2: +24V -> +5VD_ISO
- D3 pad 1: Net-(D3-K) -> -14V_ISO
- D3 pad 2: GND -> +14V_ISO
- D4 pad 1: Net-(D2-K) -> Net-(D4-K)
- D4 pad 2: Net-(D4-A) -> GND
- D5 pad 1: +5VD_ISO -> Net-(D5-K)
- D5 pad 2: Net-(D5-A) -> +24V
- J3 pad 2: +24V -> GND_ISO
- K1 pad 1: /BLOCK DIAGRAM/OUTPUT/20V_SIG -> /BLOCK DIAGRAM/OUTPUT/R20V_SIG
- K1 pad 2: /BLOCK DIAGRAM/OUTPUT/10V_SIG -> /BLOCK DIAGRAM/OUTPUT/R10V_SIG
- K1 pad 5: Net-(D5-A) -> Net-(D7-A)
- Q1 pad 4: Net-(D3-K) -> Net-(D4-K)
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
Commit message: Development
Parts:
- removed D8: 1N4148W, Diode_SMD:D_SOD-123
- removed JP1: Open, Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
- removed K1, K2: SIL05-1C90-51D, Relay_THT:Relay_SPDT_StandexMeder_SIL_Form1C
- removed U12: ISO7761FDBQ, Package_SO:SSOP-16_3.9x4.9mm_P0.635mm
- added C108: 0.1u/100V/X7R, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (179.3, 47.1)
- added D10: 1N4148W, Diode_SMD:D_SOD-123, F.Cu at (180.1, 55.0)
- added JP8: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm, F.Cu at (179.4, 67.7)
- added K4: G6SK-2F DC5, Relay_SMD:Relay_DPDT_Omron_G6SK-2F, F.Cu at (169.2, 51.1)
- added L1: RLS-226, ETH1CVOLT:RLS-226, F.Cu at (159.8, 77.0)
- added L2: 78438366047, ETH1CVOLT:78438366047, F.Cu at (120.1, 101.0)
- added L3: 78438366047, ETH1CVOLT:78438366047, F.Cu at (120.1, 108.8)
- added L4: 78438366047, ETH1CVOLT:78438366047, F.Cu at (130.0, 101.0)
- added R311: 10k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (179.3, 49.6)
- added R312: 10k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (179.3, 52.1)
- added U27: 74LV1T08GV, Package_TO_SOT_SMD:SC-74A-5_1.55x2.9mm_P0.95mm, F.Cu at (179.9, 59.1)
- added U28: ISO7760DBQ, Package_SO:SSOP-16_3.9x4.9mm_P0.635mm, F.Cu at (170.0, 67.4)
- D5: value LED -> SML-A12UTT86
- J6, J7: footprint ETH1CVOLT_A:S16N-PC -> ETH1CVOLT:S16N-PC
- JP2, JP3, JP4, JP5, JP6, JP7: footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
- R12, R13: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- R14, R15, R34, R35, R36, R37, R38, R39, R40, R41, R68, R70: footprint Package_SO:TSSOP-16_4.4x5mm_P0.65mm -> Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- U15: footprint ETH1CVOLT_A:RP-xxxxD -> ETH1CVOLT:RP-xxxxD
- Y1, Y2: footprint ETH1CVOLT_A:NX5032GA -> ETH1CVOLT:NX5032GA
- moved JP7 0.19 mm to (240.5, 83.8)
Connections:
- net /BLOCK DIAGRAM/ISO DIG/REL_RANGE_SEL renamed /BLOCK DIAGRAM/ISO DIG/REL_SET
- C76 pad 1: Net-(U18-Vout) -> +6V5_ISO
- D7 pad 2: Net-(D7-A) -> /BLOCK DIAGRAM/OUTPUT/RELAY_RESET
- Q2 pad 3: Net-(D7-A) -> /BLOCK DIAGRAM/OUTPUT/RELAY_SET
- Q3 pad 3: Net-(D8-A) -> /BLOCK DIAGRAM/OUTPUT/RELAY_RESET
- R18 pad 1: +VD_ISO -> +5VD_ISO
- R68 pad 1: /BLOCK DIAGRAM/OUTPUT/REL_RNG_SEL -> Net-(U26-Y)
- R69 pad 1: /BLOCK DIAGRAM/OUTPUT/MEAS_R20V -> GND_ISO
- R69 pad 2: GND_ISO -> /BLOCK DIAGRAM/OUTPUT/MEAS_R20V
- R70 pad 1: /BLOCK DIAGRAM/OUTPUT/REL_RNG_SEL -> Net-(U27-Y)
- U1 pad 1: /BLOCK DIAGRAM/MCU/MCU_ADC_CURR_SCLK -> unconnected-(U1-PE2-Pad1)
- U18 pad 3: Net-(U18-Vout) -> +6V5_ISO
- U26 pad 4: /BLOCK DIAGRAM/OUTPUT/REL_RNG_SEL -> Net-(U26-Y)

Commit message: Development
Parts:
- removed D10: 1N4148W, Diode_SMD:D_SOD-123
- removed J5: 1827868, Connector_Phoenix_MC:PhoenixContact_MC_1,5_2-GF-3.81_1x02_P3.81mm_Horizontal_ThreadedFlange_MountHole
- removed K4: G6SK-2F DC5, Relay_SMD:Relay_DPDT_Omron_G6SK-2F
- removed R311, R312: 10k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
- removed U28: ISO7760DBQ, Package_SO:SSOP-16_3.9x4.9mm_P0.635mm
- added D8: 1N4148W, Diode_SMD:D_SOD-123, F.Cu at (73.5, 173.5)
- added J8: FCR7350B, ETH1CVOLT:S16N-PC, F.Cu at (65.5, 154.9)
- added JP1: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm, F.Cu at (84.4, 168.4)
- added JP9: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm, F.Cu at (90.7, 149.7)
- added K1: G6SK-2F DC5, Relay_SMD:Relay_DPDT_Omron_G6SK-2F, F.Cu at (64.7, 170.0)
- added R72: 10k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (72.7, 163.1)
- added R73: 1k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (129.8, 91.8)
- added RV1: M64Y501KB40, Potentiometer_THT:Potentiometer_Bourns_3386X_Horizontal, F.Cu at (106.4, 146.9)
- added TP17: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 45.6)
- added TP18: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 49.1)
- added TP19: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 52.7)
- added TP20: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 56.2)
- added TP21: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 59.8)
- added TP22: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (199.4, 65.3)
- added TP23: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (216.8, 58.2)
- added TP24: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 58.2)
- added TP25: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 61.8)
- added TP26: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 65.3)
- added TP27: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 45.6)
- added TP28: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 49.1)
- added TP29: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (204.9, 52.7)
- added TP30: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (208.5, 45.6)
- added TP31: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (208.5, 49.1)
- added TP32: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (208.5, 52.7)
- added TP33: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (212.0, 45.6)
- added TP34: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (212.0, 49.1)
- added TP35: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (212.0, 52.7)
- added TP36: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (215.6, 45.6)
- added TP37: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (215.6, 49.1)
- added TP38: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (215.6, 52.7)
- added TP39: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (216.8, 63.8)
- added TP40: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (221.1, 45.6)
- added TP41: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (221.1, 49.1)
- added TP42: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (221.1, 52.7)
- added U12: ISO7760DBQ, Package_SO:SSOP-16_3.9x4.9mm_P0.635mm, F.Cu at (86.9, 161.4)
- J6: value FCR7350R -> 1827868; footprint ETH1CVOLT:S16N-PC -> Connector_Phoenix_MC:PhoenixContact_MC_1,5_2-GF-3.81_1x02_P3.81mm_Horizontal_ThreadedFlange_MountHole
- J7: value FCR7350B -> FCR7350R
- R23: value 8k2/0.1%/100mW -> 7k15/0.1%/100mW
- R25: value 9k65/0.1%/100mW -> 7k5/0.1%/100mW
- R26: value OPT -> 0R/5%/100mW
- R27: value 40k2/0.1%/100mW -> 8k25/0.1%/100mW
- R28: value OPT -> 8k66/0.1%/100mW
- R29: value 68k/0.1%/100mW -> 9k09/0.1%/100mW
- R30: value OPT -> 9k31/0.1%/100mW
- R31: value 110k/0.1%/100mW -> 49k9/0.1%/100mW
- R32: value 198k/0.1%/100mW -> 100/1%/100mW
- R33: value 100/1%/100mW -> 1Meg/0.1%/100mW
- R67: value 100/1%/100mW -> 10k/1%/100mW
- R70: value 1k/1%/100mW -> 10k/0.01%/100mW
- R71: value 10k/0.01%/100mW -> 100/1%/100mW
- moved R26 93.0 mm to (210.9, 57.7)
- moved R30 57.5 mm to (210.9, 62.7)
- moved R28 55.2 mm to (210.9, 60.2)
- moved J2 15.4 mm to (89.7, 128.8), turned to 180 degrees
Connections:
- J6 pad 1: Net-(D9-A2) -> Net-(J6-Pin_1)
- J7 pad 1: GND_ISO -> Net-(D9-A2)
- JP8 pad 1: GND -> Net-(JP8-A)
- JP8 pad 2: /BLOCK DIAGRAM/MCU/MCU_DEF -> Net-(J3-Pin_1)
- Q1 pad 5: Net-(J5-Pin_1) -> Net-(J6-Pin_1)
- R23 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R25 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R26 pad 1: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R26 pad 2: GND_ISO -> Net-(J4-Pin_1)
- R27 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R28 pad 1: Net-(J4-Pin_1) -> Net-(JP5-A)
- R28 pad 2: GND_ISO -> Net-(R23-Pad2)
- R29 pad 1: Net-(JP5-A) -> Net-(JP6-A)
- R29 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R30 pad 1: Net-(J4-Pin_1) -> Net-(JP7-A)
- R30 pad 2: GND_ISO -> Net-(R23-Pad2)
- R31 pad 1: Net-(JP6-A) -> Net-(JP8-A)
- R31 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R32 pad 1: Net-(JP7-A) -> Net-(U7B--)
- R32 pad 2: Net-(J4-Pin_1) -> +5VREF_ISO
- R33 pad 1: Net-(U7B--) -> Net-(JP9-A)
- R33 pad 2: +5VREF_ISO -> Net-(R23-Pad2)
- R43 pad 2: Net-(R43-Pad2) -> /BLOCK DIAGRAM/OUTPUT/R10V_SIG
- R67 pad 1: Net-(U25B--) -> /BLOCK DIAGRAM/ISO DIG/REL_SET
- R67 pad 2: /BLOCK DIAGRAM/ADC/MEAS_OUT -> GND_ISO
- R70 pad 1: Net-(U27-Y) -> /BLOCK DIAGRAM/OUTPUT/MEAS_R10V
- R70 pad 2: Net-(Q3-G) -> /BLOCK DIAGRAM/OUTPUT/MEAS_R20V
- R71 pad 1: /BLOCK DIAGRAM/OUTPUT/MEAS_R10V -> Net-(U25B--)
- R71 pad 2: /BLOCK DIAGRAM/OUTPUT/MEAS_R20V -> /BLOCK DIAGRAM/ADC/MEAS_OUT
- TP1 pad 1: Net-(D2-K-Pad3) -> /BLOCK DIAGRAM/ADC/MEAS_OUT
- TP10 pad 1: -15V_ISO -> /BLOCK DIAGRAM/ADC/ADC_SW1
- TP11 pad 1: +14V_ISO -> /BLOCK DIAGRAM/ADC/ADC_VOLT_SCLK
- TP12 pad 1: -14V_ISO -> /BLOCK DIAGRAM/DAC/DAC_~{CS}
- TP13 pad 1: +5VA_ISO -> /BLOCK DIAGRAM/DAC/DAC_~{LDAC}
- TP14 pad 1: +5VD_ISO -> /BLOCK DIAGRAM/ADC/ADC_SW2
- TP15 pad 1: +7V_ISO -> /BLOCK DIAGRAM/ADC/ADC_VOLT_~{CS}
- TP16 pad 1: -7V_ISO -> /BLOCK DIAGRAM/DAC/DAC_DIN
- TP2 pad 1: Net-(U6-VIN) -> Net-(U4-OUT)
- TP3 pad 1: Net-(U8-+REFF) -> Net-(D2-K-Pad3)
- TP4 pad 1: Net-(J3-Pin_1) -> Net-(U6-VIN)
- TP5 pad 1: Net-(J4-Pin_1) -> Net-(U8-+REFF)
- TP6 pad 1: +5VREF_ISO -> Net-(J3-Pin_1)
- TP7 pad 1: Net-(R43-Pad2) -> Net-(J4-Pin_1)
- TP8 pad 1: /BLOCK DIAGRAM/OUTPUT/R20V_SIG -> +5VREF_ISO
- TP9 pad 1: +15V_ISO -> /BLOCK DIAGRAM/DAC/DAC_SIG

Commit message: Development
Parts:
- added R74: 100/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (166.8, 103.1)
- added R75: 10k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (250.2, 69.5)
- added R76: 1k/1%/100mW, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (250.2, 72.0)
- added TP43: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (137.7, 112.4)
- added TP44: TestPoint, TestPoint:TestPoint_Pad_D1.5mm, F.Cu at (137.7, 116.0)
- C100, C101, C102, C103, C104, C35, C38, C39, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C76, C78, C80, C81, C82, C83, C85, C86, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99: footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
- C40: value 100p/100V/X7R -> 0.1u/100V/X7R
- C77: value 4u7/50V/X7R -> C; footprint Capacitor_SMD:C_1210_3225Metric_Pad1.33x2.70mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C79: value C -> 4u7/50V/X7R; footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
- R24: value 20k/0.1%/100mW -> 10k/0.01%/100mW
- R25: value 7k5/0.1%/100mW -> 10k/0.01%/100mW
- R26: value 0R/5%/100mW -> 7k5/0.1%/100mW
- R27: value 8k25/0.1%/100mW -> 0R/5%/100mW
- R28: value 8k66/0.1%/100mW -> 8k25/0.1%/100mW
- R29: value 9k09/0.1%/100mW -> 8k66/0.1%/100mW
- R30: value 9k31/0.1%/100mW -> 9k09/0.1%/100mW
- R31: value 49k9/0.1%/100mW -> 9k31/0.1%/100mW
- R32: value 100/1%/100mW -> 49k9/0.1%/100mW
- R33: value 1Meg/0.1%/100mW -> 100/1%/100mW
- R34: value 0R/5%/100mW -> 1Meg/0.1%/100mW
- R42: value 10k/0.01%/100mW -> 0R/5%/100mW
- R48: value 100k/1%/100mW -> 10k/0.01%/100mW
- R49: value 2k/1%/100mW -> 100k/1%/100mW
- R50: value 2k/1%/100mW -> 2k67/1%/250mW; footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R51: value 12k/1%/100mW -> 2k67/1%/250mW; footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R52: value 140k/1%/100mW -> 12k/1%/100mW
- R53: value 160k/1%/100mW -> 140k/1%/100mW
- R54: value 15k/1%/100mW -> 160k/1%/100mW
- R55: value 10k2/1%/100mW -> 15k/1%/100mW
- R56: value 187k/1%/100mW -> 10k/1%/100mW
- R57: value 18k/1%/100mW -> 187k/1%/100mW
- R58: value 105k/1%/100mW -> 182k/1%/100mW
- R59: value 182k/1%/100mW -> 560/1%/100mW
- R60: value 10k5/1%/100mW -> 10k/1%/100mW
- R61: value R -> 560/1%/100mW
- R62: value R -> 18k/1%/100mW
- R63: value 0R/5%/100mW -> 105k/1%/100mW
- R64: value 0R/5%/100mW -> R
- R65: value 107k/1%/100mW -> R
- R66: value 22k1/1%/100mW -> 0R/5%/100mW
- R67: value 10k/1%/100mW -> 0R/5%/100mW
- R68: value 1k/1%/100mW -> 107k/1%/100mW
- R69: value 10k/0.01%/100mW -> 22k1/1%/100mW
- R70: value 10k/0.01%/100mW -> 10k/1%/100mW
- R71: value 100/1%/100mW -> 1k/1%/100mW
- R72: value 10k/1%/100mW -> 10k/0.01%/100mW
- R73: value 1k/1%/100mW -> 10k/0.01%/100mW
- U5: value DG412xUE -> DG412CUE+
- U7: value OPA2196xD -> OPA2192ID
Connections:
- C77 pad 1: +14V_ISO -> Net-(U20-NR/SS)
- C78 pad 1: GND_ISO -> +14V_ISO
- C78 pad 2: -14V_ISO -> GND_ISO
- C79 pad 1: Net-(U20-NR/SS) -> GND_ISO
- C79 pad 2: GND_ISO -> -14V_ISO
- R24 pad 2: GND_ISO -> Net-(R24-Pad2)
- R25 pad 1: Net-(JP3-A) -> Net-(R24-Pad2)
- R25 pad 2: Net-(R23-Pad2) -> GND_ISO
- R26 pad 1: Net-(R23-Pad2) -> Net-(JP3-A)
- R26 pad 2: Net-(J4-Pin_1) -> Net-(R23-Pad2)
- R27 pad 1: Net-(JP4-A) -> Net-(R23-Pad2)
- R27 pad 2: Net-(R23-Pad2) -> Net-(J4-Pin_1)
- R28 pad 1: Net-(JP5-A) -> Net-(JP4-A)
- R29 pad 1: Net-(JP6-A) -> Net-(JP5-A)
- R30 pad 1: Net-(JP7-A) -> Net-(JP6-A)
- R31 pad 1: Net-(JP8-A) -> Net-(JP7-A)
- R32 pad 1: Net-(U7B--) -> Net-(JP8-A)
- R32 pad 2: +5VREF_ISO -> Net-(R23-Pad2)
- R33 pad 1: Net-(JP9-A) -> Net-(U7B--)
- R33 pad 2: Net-(R23-Pad2) -> +5VREF_ISO
- R34 pad 1: Net-(U9-RFB) -> Net-(JP9-A)
- R34 pad 2: /BLOCK DIAGRAM/DAC/DAC_SIG -> Net-(R23-Pad2)
- R35 pad 1: Net-(U9-INV) -> Net-(U9-RFB)
- R35 pad 2: Net-(U10--) -> /BLOCK DIAGRAM/DAC/DAC_SIG
- R36 pad 1: Net-(U10-V+) -> Net-(U9-INV)
- R36 pad 2: +7V_ISO -> Net-(U10--)
- R37 pad 1: -7V_ISO -> Net-(U10-V+)
- R37 pad 2: Net-(U10-V-) -> +7V_ISO
- R38 pad 1: Net-(U10--) -> -7V_ISO
- R38 pad 2: /BLOCK DIAGRAM/DAC/DAC_SIG -> Net-(U10-V-)
- R39 pad 1: Net-(U10-V+) -> Net-(U10--)
- R39 pad 2: +14V_ISO -> /BLOCK DIAGRAM/DAC/DAC_SIG
- R40 pad 1: -14V_ISO -> Net-(U10-V+)
- R40 pad 2: Net-(U10-V-) -> +14V_ISO
- R41 pad 1: GND_ISO -> -14V_ISO
- R42 pad 2: Net-(U13--) -> Net-(U10-V-)
- R43 pad 1: Net-(U13--) -> GND_ISO
- R43 pad 2: /BLOCK DIAGRAM/OUTPUT/R10V_SIG -> Net-(U13--)
- R44 pad 1: GND_ISO -> Net-(U13--)
- R44 pad 2: Net-(U14--) -> /BLOCK DIAGRAM/OUTPUT/R10V_SIG
- R45 pad 1: Net-(U14--) -> GND_ISO
- R45 pad 2: Net-(R45-Pad2) -> Net-(U14--)
- R46 pad 1: Net-(R45-Pad2) -> Net-(U14--)
- R47 pad 2: /BLOCK DIAGRAM/OUTPUT/R20V_SIG -> Net-(R47-Pad2)
- R48 pad 1: +24V -> Net-(R47-Pad2)
- R48 pad 2: Net-(D4-K) -> /BLOCK DIAGRAM/OUTPUT/R20V_SIG
- R49 pad 1: Net-(D6-A) -> +24V
- R49 pad 2: Net-(R49-Pad2) -> Net-(D4-K)
- R50 pad 1: Net-(R49-Pad2) -> Net-(D6-A)
- R50 pad 2: GND -> Net-(R50-Pad2)
- R51 pad 1: Net-(U19-BUF) -> Net-(R50-Pad2)
- R51 pad 2: Net-(U19-FBN) -> GND
- R52 pad 1: Net-(U19-FBN) -> Net-(U19-BUF)
- R52 pad 2: -14V_ISO -> Net-(U19-FBN)
- R53 pad 1: +14V_ISO -> Net-(U19-FBN)
- R53 pad 2: Net-(U19-FBP) -> -14V_ISO
- R54 pad 1: Net-(U19-FBP) -> +14V_ISO
- R54 pad 2: GND_ISO -> Net-(U19-FBP)
- R55 pad 1: Net-(U20-BUF) -> Net-(U19-FBP)
- R55 pad 2: Net-(U20-FBN) -> GND_ISO
- R56 pad 1: Net-(U20-FBN) -> Net-(U20-BUF)
- R56 pad 2: -22V_ISO -> Net-(U20-FBN)
- R57 pad 1: Net-(U23-BUF) -> Net-(U20-FBN)
- R57 pad 2: Net-(U23-FBN) -> -22V_ISO
- R58 pad 1: Net-(U23-FBN) -> +22V_ISO
- R58 pad 2: -7V_ISO -> Net-(U20-FBP)
- R59 pad 1: +22V_ISO -> Net-(R59-Pad1)
- R60 pad 1: Net-(U20-FBP) -> Net-(R59-Pad1)
- R61 pad 1: Net-(U21-SENSE/ADJ) -> Net-(R59-Pad1)
- R61 pad 2: GND_ISO -> Net-(U20-FBP)
- R62 pad 1: Net-(U22-SENSE/ADJ) -> Net-(U23-BUF)
- R62 pad 2: GND_ISO -> Net-(U23-FBN)
- R63 pad 1: Net-(U21-SENSE/ADJ) -> Net-(U23-FBN)
- R63 pad 2: +5VA_ISO -> -7V_ISO
- R64 pad 1: Net-(U22-SENSE/ADJ) -> Net-(U21-SENSE/ADJ)
- R64 pad 2: +5VD_ISO -> GND_ISO
- R65 pad 1: +7V_ISO -> Net-(U22-SENSE/ADJ)
- R65 pad 2: Net-(U23-FBP) -> GND_ISO
- R66 pad 1: Net-(U23-FBP) -> Net-(U21-SENSE/ADJ)
- R66 pad 2: GND_ISO -> +5VA_ISO
- R67 pad 1: /BLOCK DIAGRAM/ISO DIG/REL_SET -> Net-(U22-SENSE/ADJ)
- R67 pad 2: GND_ISO -> +5VD_ISO
- R68 pad 1: Net-(U26-Y) -> +7V_ISO
- R68 pad 2: Net-(Q2-G) -> Net-(U23-FBP)
- R69 pad 1: GND_ISO -> Net-(U23-FBP)
- R69 pad 2: /BLOCK DIAGRAM/OUTPUT/MEAS_R20V -> GND_ISO
- R70 pad 1: /BLOCK DIAGRAM/OUTPUT/MEAS_R10V -> /BLOCK DIAGRAM/ISO DIG/REL_SET
- R70 pad 2: /BLOCK DIAGRAM/OUTPUT/MEAS_R20V -> GND_ISO
- R71 pad 1: Net-(U25B--) -> Net-(U26-Y)
- R71 pad 2: /BLOCK DIAGRAM/ADC/MEAS_OUT -> Net-(Q2-G)
- R72 pad 1: /BLOCK DIAGRAM/ISO DIG/REL_RESET -> GND_ISO
- R72 pad 2: GND_ISO -> /BLOCK DIAGRAM/OUTPUT/MEAS_R20V
- R73 pad 1: Net-(U27-Y) -> /BLOCK DIAGRAM/OUTPUT/MEAS_R10V
- R73 pad 2: Net-(Q3-G) -> /BLOCK DIAGRAM/OUTPUT/MEAS_R20V
- TP31 pad 1: GND_ISO -> -22V_ISO
- TP33 pad 1: -22V_ISO -> GND_ISO
- TP34 pad 1: -7V_ISO -> +22V_ISO
- TP35 pad 1: +22V_ISO -> -7V_ISO
- TP41 pad 1: /BLOCK DIAGRAM/OUTPUT/MEAS_R10V -> /BLOCK DIAGRAM/OUTPUT/RELAY_SET
- TP42 pad 1: Net-(D9-A2) -> /BLOCK DIAGRAM/OUTPUT/MEAS_R10V

Commit message: Layout
Parts:
- moved Y2 191.0 mm to (104.9, 64.6)
- moved J6 186.0 mm to (76.5, 118.5), turned to -90 degrees
- moved C57 184.6 mm to (84.7, 115.1), turned to -90 degrees
- moved K1 181.4 mm to (204.5, 54.4), turned to 90 degrees
- moved C60 178.7 mm to (84.7, 108.7), turned to 90 degrees
- moved D7 175.7 mm to (213.9, 57.4), turned to 90 degrees
- moved C59 174.6 mm to (97.6, 128.8), turned to -90 degrees
- moved U26 170.2 mm to (190.8, 51.3), turned to 90 degrees
- moved C62 168.1 mm to (97.6, 123.2), turned to 90 degrees
- moved D8 167.6 mm to (194.4, 57.4), turned to 90 degrees
- moved C63 164.9 mm to (95.9, 108.7), turned to 90 degrees
- moved R56 160.0 mm to (139.4, 127.3)
- moved R57 159.8 mm to (139.4, 129.2)
- moved C66 159.6 mm to (123.8, 131.3), turned to 90 degrees
- moved U18 158.8 mm to (130.3, 98.6), turned to 90 degrees
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Connections:
- J6 pad 1: Net-(J6-Pin_1) -> +24V
- J6 pad 2: +24V -> Net-(J6-Pin_2)
- Q1 pad 5: Net-(J6-Pin_1) -> Net-(J6-Pin_2)
- TP24 pad 1: Net-(J6-Pin_1) -> Net-(J6-Pin_2)
Other:
- copper layers 2 -> 4

Commit message: Layout
Parts:
- added D10: BAV199, Package_TO_SOT_SMD:SOT-23, F.Cu at (179.5, 76.5)
- R40, R41: moved to B.Cu
- moved D9 169.4 mm to (206.3, 70.9), turned to 180 degrees
- moved R72 168.1 mm to (208.0, 63.2), turned to 90 degrees
- moved C37 167.5 mm to (189.4, 98.9), turned to 90 degrees
- moved R23 164.3 mm to (179.2, 95.5), turned to 90 degrees
- moved Q3 164.0 mm to (191.5, 51.9), turned to 180 degrees
- moved TP39 163.0 mm to (114.1, 77.0)
- moved C36 162.5 mm to (184.2, 91.9)
- moved R33 161.7 mm to (187.9, 91.9)
- moved C88 159.8 mm to (132.8, 89.3), turned to -90 degrees
- moved TP25 156.0 mm to (87.9, 127.8)
- moved C75 154.3 mm to (130.8, 111.4), turned to 180 degrees
- moved U19 153.6 mm to (134.8, 111.4)
- moved C73 153.6 mm to (127.1, 107.7), turned to -90 degrees
- moved D3 152.3 mm to (179.5, 68.3), turned to 90 degrees
- moved R64 151.2 mm to (136.3, 89.9), turned to -90 degrees
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